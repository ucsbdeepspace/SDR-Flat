<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>airspy_spectrum_analyzer</value></param>
<param><key>title</key><value>Airspy Spectrum Analyzer</value></param>
<param><key>author</key><value>Sahil Mahajan</value></param>
<param><key>description</key><value>Takes data from the Airspy device, performs an FFT, and records the result to a file called "audio.dat"</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pi</value></param>
<param><key>value</key><value>3.1415926535897932384626433832795028841971693993751058209749445923078164062862089986280348253421170679</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>91900000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10000000.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_rate</value></param>
<param><key>value</key><value>samp_rate/fft_size</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>sahil_addheaders</key>
<param><key>id</key><value>sahil_addheaders_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>starting_freq</key><value>center_freq - samp_rate</value></param>
<param><key>bandwidth</key><value>samp_rate</value></param>
<param><key>vec_len</key><value>fft_size</value></param>
</block>
<block>
<key>sahil_save_N_to_h5</key>
<param><key>id</key><value>sahil_save_N_to_h5_0</value></param>
<param><key>filename</key><value>sahilisanidiot.h5</value></param>
<param><key>num_items</key><value>1000</value></param>
<param><key>vec_len</key><value>fft_size</value></param>
</block>
<block>
<key>sahil_average</key>
<param><key>id</key><value>sahil_average_0</value></param>
<param><key>time</key><value>.1</value></param>
<param><key>vec_len</key><value>fft_size</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>frame_rate</key><value>frame_rate</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>.1</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>sahil_addheaders_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sahil_addheaders_0</source_block_id><sink_block_id>sahil_average_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sahil_average_0</source_block_id><sink_block_id>sahil_save_N_to_h5_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
